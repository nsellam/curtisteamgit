# Keil uVision project Project_Template.uvproj, settings and files
target NUCLEO-F103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\..\LIB\CMSIS\CM3\CoreSupport;..\..\LIB\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\LIB\STM32F10x_StdPeriph_Driver\inc;..\..\LIB\CurtisLib\StdPeriph_Ex;..\..\LIB\CurtisLib\Drivers_Car;..\..\LIB\CurtisLib\Common;..\Services;..\Application;..\MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c manager.c frontmotor_example.c mirroring_example.c positionsensor_example.c rearmotors_example.c speedsensor_example.c
  group Drivers_Car
    ../../LIB/CurtisLib/Drivers_Car/: battery.c data_interface.c driver_callbacks.c frame_check.c front_motor.c hall_sensors.c init.c mirroring.c motors.c position_sensors.c rear_motors.c speed_sensors.c spi_comm.c system_time.c us_sensors.c
  group StdPeriph_Ex
    ../../LIB/CurtisLib/StdPeriph_Ex/: adc.c debug.c dma.c exti.c gpio.c it_handlers.c nvic.c pwm.c spi.c systick.c tim.c tim_ic.c
  group Common
    ../../LIB/CurtisLib/Common/: common_constants.h
  group StdPeriph
    ../../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../LIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../LIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
