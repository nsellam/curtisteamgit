# Keil uVision project Demo_Sprint2.uvproj, settings and files
target NUCLEO-F103RB (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\..\..\Lib_STM32\CMSIS\CM3\CoreSupport;..\..\..\Lib_STM32\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\Lib_STM32\STM32F10x_StdPeriph_Driver\inc;..\..\..\Lib_STM32\CurtisLib\Drivers_STM;..\..\..\Lib_COM\CurtisLib\HDM_API\inc;..\..\..\Lib_COM\CurtisLib\XPS_API\inc;..\Drivers;..\Services;..\Application
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c position_sensor.c speed_sensor.c car.c
  group Services
    ../Services/: uncompress.c mirroring_st.c motor.c callbacks_services.c hall_sensor.c compress.c adc.c ultrasonic.c
    ../../../Lib_COM/CurtisLib/HDM_API/src/: data.c
  group Drivers
    ../Drivers/: stm32f10x_conf.h stm32f10x_it.c spicomm_st.c framecheck.c pwm.c timer.c exti.c gpio.c systick.c capture.c
  group StdPeriph
    ../../../Lib_STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../../Lib_STM32/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../Lib_STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../../Lib_STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
